# Keil uVision project tamagotchi.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tamagotchi
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c
  group startup
    ./: startup_LPC17xx.s
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: AsciiLib.c GLCD.c HzLib.c GLCD.h AsciiLib.h HzLib.h
  group joystick
    ./joystick/: joystick.h lib_joystick.c
  group drawing
    ./drawing/: drawing.c drawing.h
  group images
    ./images/: imagedata.h idle.c idle_2.c running1.c running2.c running5.c running6.c crouched.c pizza.c donut.c eatingdonut.c eatingpizza.c touched1.c touched2.c touched3.c mute.c volume1.c volume2.c volume3.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group ADC
    ./adc/: IRQ_adc.c lib_adc.c adc.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
software components: CMSIS:CORE 5.5.0
